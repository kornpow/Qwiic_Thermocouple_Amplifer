# Repository kornpow/Qwiic_Thermocouple_Amplifer

File README.md:

SparkFun MCP9600 Thermocouple Amplifier
========================================

<table class="table table-hover table-striped table-bordered">
    <tr>
        <th class="text-center"> 
        </th>
        <th class="text-center">
        </th>
    </tr>
    <tr align="center">
        <td></td>
        <td></td>
    </tr>
    <tr align="center">
        <td>SparkFun MCP9600 Thermocouple Amplifier - PCC Connector (SEN-16294)</td>
        <td>SparkFun MCP9600 Thermocouple Amplifier - Screw Terminals (SEN-16295)</td>
    </tr>
</table>

The MCP9600 is an integrated thermocouple amplifier featuring a typical accuracy of ±0.5°C and a maximum accuracy of ±1.5°C, with support for many thermocouple types, conversion modes, and a configurable exponential moving average filter.

Repository Contents
-------------------

* **/Documentation** - Data sheets, additional product information
* **/Hardware** - Eagle design files (.brd, .sch)
* **/Production** - Production panel files (.brd)

Documentation
--------------
* **[Thermocouple Amplifier Hookup Guide](https://learn.sparkfun.com/tutorials/sparkfun-qwiic-thermocoupler-hookup-guide)** - Hookup guide for the SparkFun Thermocouple Amplifiers.
* **[SparkFun MCP9600 Arduino Library](https://github.com/sparkfun/SparkFun_MCP9600_Arduino_Library)** - Arduino library for the MCP9600.

License Information
-------------------

This product is _**open source**_! 

Please review the LICENSE.md file for license information. 

If you have any questions or concerns on licensing, please contact technical support on our [SparkFun forums](https://forum.sparkfun.com/viewforum.php?f=152).

Distributed as-is; no warranty is given.

- Your friends at SparkFun.

_<COLLABORATION CREDIT>_

## EAGLE design Hardware/SparkFun_Qwiic_Thermocouple_Amplifier_PCC/SparkFun_Qwiic_Thermocouple_Amplifier_PCC.brd

Board: 2 copper layers, 25.4 x 39.4 mm, 50 parts (18 on the bottom side), 15 nets.

Parts:
C1: 0.1uF; 0603
D1: RED; LED-0603
FD1, FD2, FD3, FD4: FIDUCIALUFIDUCIAL; FIDUCIAL-MICRO
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
J1: PTH; 1X04_NO_SILK
J2, J3: QWIIC; JST04_1MM_RA
J4: 1X04_NO_SILK
J5: PCB_THERMOCOUPLE; PCC-SMP
JP1, JP3: SMT-JUMPER_2_NC_TRACE_SILK
JP2: I2C; SMT-JUMPER_3_2-NC_TRACE_SILK
JP8, JP9: STAND-OFF
LOGO1: OSHW-LOGOMINI; OSHW-LOGO-MINI
LOGO2: SFE_LOGO_NAME_FLAME.1_INCH; SFE_LOGO_NAME_FLAME_.1
LOGO3: QWIIC_LOGO_5MM; QWIIC_5MM
R1: 1k; 0603
R2: AXIAL-0.3-KIT
R3: 10k; 0603
R4, R5: 2.2k; 0603
U1: MCP9600-SMD; MQFN-20
U$1, U$5: #ALT30
U$2: R21
U$3, U$8: #ALT10
U$4, U$18: #ALT20
U$6: QWIIC_THERMOCOUPLE2
U$7, U$11: #ALT40
U$9, U$12: SCL-[)
U$10, U$23: GND-04
U$13, U$14: SDA-[)
U$15: PWR0
U$16, U$19: 3V31
U$17: SFE_LOGO_NAME_FLAME_.1
U$20: LED0
U$21: I_SUPER2_C-()-04
U$22: ADDR1
U$25: AMPLIFIER2

Connections:
3.3V: C1.1, J1.2, J2.2, J3.2, JP2.2, JP3.2, R3.2, U1.8
!ALT1: J4.1, U1.11
!ALT2: J4.2, U1.12
!ALT3: J4.3, U1.14
!ALT4: J4.4, U1.15
ADDR: JP1.1, R2.P$2, R3.1, U1.16
GND: C1.2, D1.C, J1.1, J2.1, J3.1, JP1.2, R2.P$1, U1.1, U1.3, U1.5, U1.6, U1.7, U1.9, U1.10, U1.13, U1.17, U1.18, U1.21
unnamed: D1.A, R1.2
unnamed: JP2.1, R5.2
unnamed: JP2.3, R4.2
unnamed: J5.+, U1.2
unnamed: J5.-, U1.4
unnamed: JP3.1, R1.1
SCL: J1.4, J2.4, J3.4, R5.1, U1.19
SDA: J1.3, J2.3, J3.3, R4.1, U1.20

## EAGLE design Hardware/SparkFun_Qwiic_Thermocouple_Amplifier.brd

Parts:
C1: 0.1uF; 0603
D1: RED; LED-0603
FD1, FD2, FD3, FD4: FIDUCIAL1X2; FIDUCIAL-1X2
FRAME1: FRAME-LETTER; CREATIVE_COMMONS
I2C: JUMPER-SMT_3_2-NC_TRACE_SILK; SMT-JUMPER_3_2-NC_TRACE_SILK
J1: PTH; 1X04_NO_SILK
J2, J3: QWIIC_CONNECTORJS-1MM; JST04_1MM_RA
J4: CONN_041X04_NO_SILK; 1X04_NO_SILK
JP1: JUMPER-SMT_2_NO_SILK; SMT-JUMPER_2_NO_SILK
JP2: PCB_THERMOCOUPLE; PCC-SMP
JP3: JUMPER-SMT_2_NC_TRACE_SILK; SMT-JUMPER_2_NC_TRACE_SILK
JP8, JP9: STAND-OFF
LOGO1: OSHW-LOGOMINI; OSHW-LOGO-MINI
LOGO2: SFE_LOGO_NAME.1_INCH; SFE_LOGO_NAME_.1
LOGO3: QWIIC_LOGO_5MM; QWIIC_5MM
R1: 1k; 0603
R2: 43k; 0603
R3: 10k; 0603
R4, R5: 2.2k; 0603
U16: MCP9600-SMD; MQFN-20

Connections:
3.3V: C1.1, I2C.2, J1.2 (VCC), J2.2, J3.2, JP3.2, R3.2, U16.8 (VDD)
!ALT1: J4.1, U16.11 (ALERT1)
!ALT2: J4.2, U16.12 (ALERT2)
!ALT3: J4.3, U16.14 (ALERT3)
!ALT4: J4.4, U16.15 (ALERT4)
ADDR: JP1.1, R2.1, R3.1, U16.16 (ADDR)
GND: C1.2, D1.C, J1.1 (GND), J2.1, J3.1, JP1.2, R2.2, U16.1 (GND), U16.3 (GND), U16.5 (GND), U16.6 (GND), U16.7 (GND), U16.9 (GND), U16.10 (GND), U16.13 (GND), U16.17 (GND), U16.18 (GND), U16.21 (GND)
unnamed: D1.A, R1.2
unnamed: I2C.1, R5.2
unnamed: I2C.3, R4.2
unnamed: JP2.+, U16.2 (V+)
unnamed: JP2.-, U16.4 (V-)
unnamed: JP3.1, R1.1
SCL: J1.4 (SCL), J2.4, J3.4, R5.1, U16.19 (SCL)
SDA: J1.3 (SDA), J2.3, J3.3, R4.1, U16.20 (SDA)

Notes on the sheet:
I2C Connections
MCP9600 Thermocouple EMF to Temperature Converter
Fischer Moseley
Clear jumper to remove I2C pullups
MCP9600 Address Selection: 0x60: ADDR tied to GND 0x61: R3 = 10k, R2 = 2.2k 0x62: R3 = 10k, R2 = 4.3k 0x63: R3 = 10k, R2 = 7.5k 0x64: R3 = 10k, R2 = 13k 0x65: R3 = 10k, R2 = 22k 0x66: R3 = 10k, R2 = 43k (default) 0x67: ADDR Pin Tied to VDD
v10
Revised by: Alex Wende

Board: 2 copper layers, 22.9 x 39.4 mm, 49 parts (18 on the bottom side), 15 nets.

Other parts of the board:
U$1, U$5: #ALT30
U$2: ADR_#_0X600
U$3, U$8: #ALT10
U$4, U$18: #ALT20
U$6: QWIIC_THERMOCOUPLE2
U$7, U$11: #ALT40
U$9, U$12: SCL-[)
U$10, U$23: GND-04
U$13, U$14: SDA-[)
U$16: LED1
U$17: SFE_LOGO_NAME_FLAME_.1
U$19, U$22: 3.3V
U$20: PWR-()-04
U$21: I_SUPER2_C-()-04
U$25: AMPLIFIER2

## Commit log

2020-01-28 Added screw terminal board
2020-01-30 Design review changes
2020-01-30 Update SparkFun_Qwiic_Thermocouple_Amplifier_PCC.brd
    - Mitered SCL trace on qwiic connector
2023-12-13 convert to kicad using tool and adjust folder structure

Notices in the files:
parts and their libraries:
SparkFun-Capacitors: Licensing: Creative Commons ShareAlike 4.0 International - https://creativecommons.org/licenses/by-sa/4.0
SparkFun-Aesthetics: Released under the Creative Commons Attribution Share-Alike 4.0 License
SparkFun-Aesthetics: https://creativecommons.org/licenses/by-sa/4.0
